FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://fast-boot.cfg"
